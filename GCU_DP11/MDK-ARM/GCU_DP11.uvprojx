# Keil uVision project GCU_DP11.uvprojx, settings and files
target GCU_DP11 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F767VITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: GCU_DP11 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx
  c include: ../Inc;      ../Drivers/STM32F7xx_HAL_Driver/Inc;      ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;      ../Drivers/CMSIS/Device/ST/STM32F7xx/Include;      ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32f767xx.s
  group S-Function Wrappers
    ../Src/S-Function_Wrappers/: ClutchMotor_init_wrapper.c ClutchMotor_setPosition_wrapper.c ClutchMotor_setupPWM_wrapper.c Efi_init_wrapper.c Efi_setBlip_wrapper.c Efi_setCut_wrapper.c Efi_setRPMLimiter_wrapper.c Efi_unsetBlip_wrapper.c Efi_unsetCut_wrapper.c Efi_unsetRPMLimiter_wrapper.c EngineControl_start_wrapper.c EngineControl_stop_wrapper.c GearMotor_brake_wrapper.c GearMotor_init_wrapper.c GearMotor_release_wrapper.c GearMotor_turnLeft_wrapper.c GearMotor_turnRight_wrapper.c InitTimer_wrapper.c InitUART_wrapper.c load_accParameters_wrapper.c load_default_timings_wrapper.c PackCANMsg_wrapper.c PackCanUART_wrapper.c PackUARTMsg_wrapper.c sendCAN_wrapper.c sendUART_wrapper.c UnpackCanUART_wrapper.c UnpackUARTMsg_wrapper.c update_ADC_data_wrapper.c CAN_Filter_Setup_wrapper.c CAN_Start_wrapper.c Read_oil_sensor_wrapper.c ScanADC_wrapper.c CAN_Load_id_wrapper.c Eeprom_init_wrapper.c Eeprom_read_wrapper.c Eeprom_write_wrapper.c
  group Application/User
    ../Src/: GCU_Model_genCode.c GCU_Model_genCode_data.c main.c gpio.c adc.c can.c dma.c gfxsimulator.c i2c.c tim.c usart.c stm32f7xx_it.c stm32f7xx_hal_msp.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cortex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
software components: CMSIS:CORE 4.3.0
